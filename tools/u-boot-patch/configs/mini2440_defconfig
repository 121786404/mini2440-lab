## tools/u-boot-patch/configs/mini2440_defconfig
```kconfig
CONFIG_ARM=y
CONFIG_TARGET_MINI2440=y
CONFIG_HUSH_PARSER=y
CONFIG_SYS_PROMPT="MINI2440 # "
CONFIG_BOOTDELAY=5
```
